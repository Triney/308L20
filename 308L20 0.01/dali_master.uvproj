# Keil uVision project dali_master.uvproj, settings and files
target R308L20 (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: dali_master +hex
  c flags: Optim=1
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group cmsis
    ./: startup_LPC11xx.s
    ./src/: system_LPC11xx.c core_cm0.c
  group code
    ./main/: main.c
    ./src/: PanDali_cmd.c sft_tmr.c sft_tmr_apps.c
  group std_peripherals
    ./src/: timer32.c timer16.c wdt.c gpio.c uart.c
  group driver
    ./src/: dali_master.c dali_master_3rd.c dali_master_2nd.c i2c1.c drv_keyscan.c
